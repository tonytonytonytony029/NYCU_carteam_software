# IAR project 17010_vmu.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: RS485_HALFDUPLEX; SHELL_NO_PROMOTE; SHELL_ECHO=1; USE_MASTER; PACK_STRUCT_USE_INCLUDES
  ICCARM.CCIncludePath2: ; ..\board; ..\inc; ..\conf; ..\src\fmbport; ..\src\udpserver; $osRoot$\os\common\startup\armcmx\devices\stm32f4xx; $osRoot$\os\common\ports\armcmx; $osRoot$\os\common\ports\armcmx\compilers\iar; $osRoot$\os\common\ports\armcmx\os\common\oslib\include; $osRoot$\os\common\ext\CMSIS\ST\STM32F4xx; $osRoot$\os\common\ext\cmsis\include; $osRoot$\os\common\ext\cmsis\generic; $osRoot$\os\common\abstractions\cmsis_os; $osRoot$\os\common\oslib\include; $osRoot$\os\hal\include; $osRoot$\os\hal\lib\streams; $osRoot$\os\hal\osal\lib; $osRoot$\os\hal\osal\rt; $osRoot$\os\hal\rt; $osRoot$\os\hal\ports\common\armcmx; $osRoot$\os\hal\ports\STM32\LLD\ADCv2; $osRoot$\os\hal\ports\STM32\LLD\CANv1; $osRoot$\os\hal\ports\STM32\LLD\DACv1; $osRoot$\os\hal\ports\STM32\LLD\DMAv2; $osRoot$\os\hal\ports\STM32\LLD\EXTIv1; $osRoot$\os\hal\ports\STM32\LLD\GPIOv2; $osRoot$\os\hal\ports\STM32\LLD\I2Cv1; $osRoot$\os\hal\ports\STM32\LLD\MACv1; $osRoot$\os\hal\ports\STM32\LLD\OTGv1; $osRoot$\os\hal\ports\STM32\LLD\RTCv2; $osRoot$\os\hal\ports\STM32\LLD\SDIOv1; $osRoot$\os\hal\ports\STM32\LLD\SDMMCv1; $osRoot$\os\hal\ports\STM32\LLD\SPIv1; $osRoot$\os\hal\ports\STM32\LLD\TIMv1; $osRoot$\os\hal\ports\STM32\LLD\USARTv1; $osRoot$\os\hal\ports\STM32\LLD\USBv1; $osRoot$\os\hal\ports\STM32\LLD\xWDGv1; $osRoot$\os\hal\ports\STM32\STM32F4xx; $osRoot$\os\rt\include; $osRoot$\os\various; $osRoot$\os\various\lwip_bindings\; $osRoot$\os\various\lwip_bindings; $osRoot$\os\various\shell; $osRoot$\os\license; $osRoot$\ext\fatfs\src; $osRoot$\ext\lwip\src\include; $osRoot$\ext\lwip\src\include\ipv4; $extsource$\freemodbus; $extsource$\freemodbus\include; $extsource$\freemodbus\rtu; $extsource$\freemodbus\ascii; $extsource$\freemodbus\tcp; $extsource$\haoyi_lib\at24eep; $extsource$\haoyi_lib\adc; $extsource$\ChibiOS\ChibiOS_17.6.2\os\ex\Micron; $extsource$\ChibiOS\ChibiOS_17.6.2\os\hal\lib\peripherals\flash; $extsource$\haoyi_lib\ntc; $extsource$\haoyi_lib\eeprom
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ; ..\inc; ..\conf; $osRoot$\os\common\startup\armcmx\devices\stm32f4xx; $osRoot$\os\common\ports\armcmx; $osRoot$\os\common\ports\armcmx\compilers\iar; $osRoot$\os\common\ports\armcmx\os\common\oslib\include; $osRoot$\os\common\ext\CMSIS\ST\STM32F4xx; $osRoot$\os\common\ext\cmsis\include; $osRoot$\os\common\ext\cmsis\generic; $osRoot$\os\common\abstractions\cmsis_os; $osRoot$\os\hal\include; $osRoot$\os\hal\lib\streams; $osRoot$\os\hal\osal\lib; $osRoot$\os\hal\rt; $osRoot$\os\hal\ports\common\armcmx; $osRoot$\os\hal\ports\STM32\LLD\ADCv1; $osRoot$\os\hal\ports\STM32\LLD\CANv1; $osRoot$\os\hal\ports\STM32\LLD\DACv1; $osRoot$\os\hal\ports\STM32\LLD\DMAv1; $osRoot$\os\hal\ports\STM32\LLD\EXTIv1; $osRoot$\os\hal\ports\STM32\LLD\GPIOv1; $osRoot$\os\hal\ports\STM32\LLD\I2Cv1; $osRoot$\os\hal\ports\STM32\LLD\MACv1; $osRoot$\os\hal\ports\STM32\LLD\OTGv1; $osRoot$\os\hal\ports\STM32\LLD\RTCv1; $osRoot$\os\hal\ports\STM32\LLD\SDIOv1; $osRoot$\os\hal\ports\STM32\LLD\SDMMCv1; $osRoot$\os\hal\ports\STM32\LLD\SPIv1; $osRoot$\os\hal\ports\STM32\LLD\TIMv1; $osRoot$\os\hal\ports\STM32\LLD\USARTv1; $osRoot$\os\hal\ports\STM32\LLD\USBv1; $osRoot$\os\hal\ports\STM32\LLD\xWDGv1; $osRoot$\os\hal\ports\STM32\STM32F4xx; $osRoot$\os\rt\include; $osRoot$\os\various; $osRoot$\os\various\lwip_bindings\; $osRoot$\os\various\lwip_bindings\arch; $osRoot$\os\various\shell; $osRoot$\os\license
  OBJCOPY.OOCOutputFile: 17010_vmu.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: C:\Users\nctur\Documents\Soft&Firmware\VCU\VCU related file\17010_can_controller-master\ch_stm32f407.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group board
    ../board/: board.c board.h
  group conf
    ../inc/: chconf.h halconf.h lwipopts.h mcuconf.h
  group ext/fatfs
    $osRoot$/ext/fatfs/src/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c integer.h
  group ext/freemodbus
    $extsource$/freemodbus/: mb.c mb_hy.c
    $extsource$/freemodbus/ascii/: mbascii.c
    $extsource$/freemodbus/rtu/: mbcrc.c mbrtu.c
    $extsource$/freemodbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    $extsource$/freemodbus/tcp/: mbtcp.c
  group ext/freemodbus_gd
    $extsource$/freemodbus_gd/: mb_hy.c
  group ext/freemodbus_gd/ascii
    $extsource$/freemodbus_gd/ascii/: mbascii.c
  group ext/freemodbus_gd/function
    $extsource$/freemodbus_gd/functions/: mbfunccoils.c mbfunccoils_m.c mbfuncdiag.c mbfuncdisc.c mbfuncdisc_m.c mbfuncholding.c mbfuncholding_m.c mbfuncinput.c mbfuncinput_m.c mbfuncother.c mbutils.c
  group ext/freemodbus_gd/include
    $extsource$/freemodbus_gd/include/: mbport.h
  group ext/freemodbus_gd/rtu
    $extsource$/freemodbus_gd/rtu/: mbcrc.c mbrtu.c
  group ext/freemodbus_gd/tcp
    $extsource$/freemodbus_gd/tcp/: mbtcp.c
  group ext/lwip
    $osRoot$/ext/lwip/src/netif/: etharp.c
  group ext/lwip/api
    $osRoot$/ext/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group ext/lwip/core
    $osRoot$/ext/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group ext/lwip/core/ipv4
    $osRoot$/ext/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group ext/lwip/netif
    $osRoot$/ext/lwip/src/netif/: ethernetif.c slipif.c
  group ext/lwip/netif/ppp
    $osRoot$/ext/lwip/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group hal/common
    $osRoot$/os/hal/ports/common/ARMCMx/: nvic.c
  group hal/lib/streams
    $osRoot$/os/hal/lib/streams/: chprintf.c memstreams.c nullstreams.c
  group hal/osal
    $osRoot$/os/hal/osal/rt/: osal.c
  group hal/source
    $osRoot$/os/hal/src/: hal.c hal_adc.c hal_buffers.c hal_can.c hal_dac.c hal_ext.c hal_gpt.c hal_i2c.c hal_i2s.c hal_icu.c hal_mac.c hal_mmc_spi.c hal_mmcsd.c hal_pal.c hal_pwm.c hal_qspi.c hal_queues.c hal_rtc.c hal_sdc.c hal_serial.c hal_serial_usb.c hal_spi.c hal_st.c hal_uart.c hal_usb.c hal_wdg.c
  group hal/stm32
    $osRoot$/os/hal/ports/STM32/LLD/ADCv2/: hal_adc_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/CANv1/: hal_can_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/DACv1/: hal_dac_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/EXTIv1/: hal_ext_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/TIMv1/: hal_gpt_lld.c hal_icu_lld.c hal_pwm_lld.c hal_st_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/I2Cv1/: hal_i2c_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/SPIv1/: hal_i2s_lld.c hal_spi_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/MACv1/: hal_mac_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/GPIOv2/: hal_pal_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/RTCv2/: hal_rtc_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/SDIOv1/: hal_sdc_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/USARTv1/: hal_serial_lld.c hal_uart_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/USBv1/: hal_usb_lld.c
    $osRoot$/os/hal/ports/STM32/LLD/DMAv2/: stm32_dma.c
  group hal/stm32/f4
    $osRoot$/os/hal/ports/STM32/STM32F4xx/: hal_ext_lld_isr.c hal_lld.c
  group os/common
    $osRoot$/os/common/ports/ARMCMx/: chcore.c chcore_v7m.c
    $osRoot$/os/common/ports/ARMCMx/compilers/IAR/: chcoreasm_v7m.s
    $osRoot$/os/common/oslib/src/: chheap.c chmboxes.c chmemcore.c chmempools.c
    $osRoot$/os/common/abstractions/cmsis_os/: cmsis_os.c
    $osRoot$/os/common/startup/ARMCMx/compilers/IAR/: cstartup.s vectors.s
  group os/rt
    $osRoot$/os/rt/src/: chcond.c chdebug.c chdynamic.c chevents.c chmsg.c chmtx.c chregistry.c chschd.c chsem.c chstats.c chsys.c chthreads.c chtm.c chtrace.c chvt.c
  group os/various
    $osRoot$/os/various/: evtimer.c
  group os/various/fatfs_bindings
    $osRoot$/os/various/fatfs_bindings/: fatfs_diskio.c fatfs_syscall.c
  group os/various/lwip_bindings
    $osRoot$/os/various/lwip_bindings/: lwipthread.c
    $osRoot$/os/various/lwip_bindings/arch/: sys_arch.c
  group os/various/shell
    $osRoot$/os/various/shell/: shell.c shell_cmd.c
  group Source
    ../src/: digital_io.c filesys.c hal_ad7124.c peripheral_if.c speed_io.c sysParam.c thermocouple.c
    ../src/modbusPort/: mbTask.c
    ../src/fmbPort/: mbTask.c
  group Source/ad5593r
    $extsource$/haoyi_lib/adc/: ad5593r.c
  group Source/at24_eep
    $extsource$/haoyi_lib/eeprom/: at24_eep.c
  group Source/fmbPort
    ../src/fmbPort/: portevent.c portother.c portserial - old.c portserial.c porttcp - netconn.c porttcp.c porttimer.c
  group Source/m25_flash
    $osRoot$/os/hal/lib/peripherals/flash/: hal_flash.c hal_jesd216_flash.c
    $osRoot$/os/ex/Micron/: m25q.c
  group Source/modbusPort
    ../src/modbusPort/: mbconfig.h mbTask.h port.h portevent.c portother.c portserial.c porttcp.c porttimer.c
  group Source/MRAM
    $extsource$/haoyi_lib/eeprom/: mrxx.c mrxx.h
  group Source/NTC
    $extsource$/haoyi_lib/ntc/: ntc.c
  group Source/udpServer
    ../src/udpServer/: udpServer.c
  group Source/vmu
    ../src/: vmu.c
