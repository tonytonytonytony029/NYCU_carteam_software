<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\17010_can_controller-master\app\17010_vmu.ewp</path>
    </project>
    <batchBuild />
</workspace>
