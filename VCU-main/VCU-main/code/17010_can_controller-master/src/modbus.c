#include <ch.h>
#include <hal.h>

#include "modbus.h"
#include "VCU.h"

#include "ch.h"
#include "hal.h"

#define ConsoleDriver SYS_CONSOLE_CH
#define PortDriver SYS_MODBUS_CH
#define MB_SER_PDU_SIZE_MAX     256 
#define RCV_RANGE 5
#define STC_PERIOD 1000

modbus_t modbus_dev = {0};

modbus_block_t blocklist[] = {
  {4, ntc_1},
  {4, ntc_2},
  {8, ntc_4},
  {6, ntc_4},
  {3, ntc_5}
};

static const uint8_t aucCRCHi[] = {
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 
    0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41, 
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x00, 0xC1, 0x81, 0x40,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40, 0x01, 0xC0, 0x80, 0x41, 0x01, 0xC0, 0x80, 0x41,
    0x00, 0xC1, 0x81, 0x40
};

static const uint8_t aucCRCLo[] = {
    0x00, 0xC0, 0xC1, 0x01, 0xC3, 0x03, 0x02, 0xC2, 0xC6, 0x06, 0x07, 0xC7,
    0x05, 0xC5, 0xC4, 0x04, 0xCC, 0x0C, 0x0D, 0xCD, 0x0F, 0xCF, 0xCE, 0x0E,
    0x0A, 0xCA, 0xCB, 0x0B, 0xC9, 0x09, 0x08, 0xC8, 0xD8, 0x18, 0x19, 0xD9,
    0x1B, 0xDB, 0xDA, 0x1A, 0x1E, 0xDE, 0xDF, 0x1F, 0xDD, 0x1D, 0x1C, 0xDC,
    0x14, 0xD4, 0xD5, 0x15, 0xD7, 0x17, 0x16, 0xD6, 0xD2, 0x12, 0x13, 0xD3,
    0x11, 0xD1, 0xD0, 0x10, 0xF0, 0x30, 0x31, 0xF1, 0x33, 0xF3, 0xF2, 0x32,
    0x36, 0xF6, 0xF7, 0x37, 0xF5, 0x35, 0x34, 0xF4, 0x3C, 0xFC, 0xFD, 0x3D,
    0xFF, 0x3F, 0x3E, 0xFE, 0xFA, 0x3A, 0x3B, 0xFB, 0x39, 0xF9, 0xF8, 0x38, 
    0x28, 0xE8, 0xE9, 0x29, 0xEB, 0x2B, 0x2A, 0xEA, 0xEE, 0x2E, 0x2F, 0xEF,
    0x2D, 0xED, 0xEC, 0x2C, 0xE4, 0x24, 0x25, 0xE5, 0x27, 0xE7, 0xE6, 0x26,
    0x22, 0xE2, 0xE3, 0x23, 0xE1, 0x21, 0x20, 0xE0, 0xA0, 0x60, 0x61, 0xA1,
    0x63, 0xA3, 0xA2, 0x62, 0x66, 0xA6, 0xA7, 0x67, 0xA5, 0x65, 0x64, 0xA4,
    0x6C, 0xAC, 0xAD, 0x6D, 0xAF, 0x6F, 0x6E, 0xAE, 0xAA, 0x6A, 0x6B, 0xAB, 
    0x69, 0xA9, 0xA8, 0x68, 0x78, 0xB8, 0xB9, 0x79, 0xBB, 0x7B, 0x7A, 0xBA,
    0xBE, 0x7E, 0x7F, 0xBF, 0x7D, 0xBD, 0xBC, 0x7C, 0xB4, 0x74, 0x75, 0xB5,
    0x77, 0xB7, 0xB6, 0x76, 0x72, 0xB2, 0xB3, 0x73, 0xB1, 0x71, 0x70, 0xB0,
    0x50, 0x90, 0x91, 0x51, 0x93, 0x53, 0x52, 0x92, 0x96, 0x56, 0x57, 0x97,
    0x55, 0x95, 0x94, 0x54, 0x9C, 0x5C, 0x5D, 0x9D, 0x5F, 0x9F, 0x9E, 0x5E,
    0x5A, 0x9A, 0x9B, 0x5B, 0x99, 0x59, 0x58, 0x98, 0x88, 0x48, 0x49, 0x89,
    0x4B, 0x8B, 0x8A, 0x4A, 0x4E, 0x8E, 0x8F, 0x4F, 0x8D, 0x4D, 0x4C, 0x8C,
    0x44, 0x84, 0x85, 0x45, 0x87, 0x47, 0x46, 0x86, 0x82, 0x42, 0x43, 0x83,
    0x41, 0x81, 0x80, 0x40
};

uint8_t txmsg[8] = {0};
uint8_t rxmsg[MB_SER_PDU_SIZE_MAX] ={0};
uint16_t crc = 0;
static size_t RecvAmount = 0;
static uint8_t turn = 0;
static uint8_t statistic[5]= {0};



uint16_t MBCRC16( uint8_t * pucFrame, uint16_t usLen )
{
    uint8_t           ucCRCHi = 0xFF;
    uint8_t           ucCRCLo = 0xFF;
    int             iIndex;

    while( usLen-- )
    {
        iIndex = ucCRCLo ^ *( pucFrame++ );
        ucCRCLo = ( uint8_t )( ucCRCHi ^ aucCRCHi[iIndex] );
        ucCRCHi = aucCRCLo[iIndex];
    }
    return ( uint16_t )( ucCRCHi << 8 | ucCRCLo );
}

modbus_error_t request(int8_t id, int16_t pos, int16_t num){
    if(modbus_dev.turn_on_flag != 1) return NOT_init;

    txmsg[0] = id;
    txmsg[1] = 3;
    txmsg[2] = pos >>8;
    txmsg[3] = pos;
    txmsg[4] = num >> 8;
    txmsg[5] = num;

    crc = MBCRC16(txmsg, 6);
    txmsg[6] = crc ;
    txmsg[7] = crc >>8;

    sdWrite(&PortDriver, txmsg, 8);

    chThdSleepMilliseconds(20);

    RecvAmount = sdReadTimeout(&PortDriver, rxmsg, 1+1+1+ num*2 +2 +2, MS2ST(500));

    if(RecvAmount == 0) return RCV_Empty;
    if(rxmsg[0] != id) return RCV_address;
    if(MBCRC16(rxmsg, 1+1+1+ num*2 +2) != 0) return CRC_error; 
    

    for(int i = 0 ; i < num ; i++){
        modbus_dev.usMRegHoldBuf[id-1][pos+i] = rxmsg[3+i*2]<<8 | rxmsg[3+i*2+1];
    }

    return NO_ERROR;
}

void MB_readHoldingRegister(int8_t id, int16_t pos, int16_t num){

  modbus_dev.state = request(id, pos ,num);
  modbus_dev.OnSendId = id;
  
  //modbus_dev.flop = ~modbus_dev.flop;
  statistic[modbus_dev.state] += 1;
  turn+=1;
  if(turn == STC_PERIOD){
    turn =0;
    
  }

}

bool MB_init(void){
    /*nothing need to do so far*/
    modbus_dev.turn_on_flag =1;
    modbus_dev.state = NO_ERROR;
    //modbus_dev.flop = 0;
    modbus_dev.OnSendId = 0;
    return TRUE;
}

void print(int id){
  chprintf((BaseSequentialStream*)&ConsoleDriver, " BMS %d, ", id);
  
  for(int i = 0; i < 12; i++){
    chprintf((BaseSequentialStream*)&ConsoleDriver, "%d, ", modbus_dev.usMRegHoldBuf[id-1][i]);
  }
  for(int i = 0; i < 5; i++){
    chprintf((BaseSequentialStream*)&ConsoleDriver, "%d, ", modbus_dev.usMRegHoldBuf[id-1][i+17]);
  }
  
  chprintf((BaseSequentialStream*)&ConsoleDriver, "\r\n");
}

void MB_print_ALL(){
    chprintf((BaseSequentialStream*)&ConsoleDriver, " BMS NUM, ");

    for(int i = 0; i < 12; i++){
      chprintf((BaseSequentialStream*)&ConsoleDriver, "Vltg %d, ", i);
    }
    for(int i = 0; i < 5; i++){
      chprintf((BaseSequentialStream*)&ConsoleDriver, "Temp %d, ", i);
    }
    chprintf((BaseSequentialStream*)&ConsoleDriver, "\r\n");
    
    for(int i = 1; i<=10; i++){
      print(i);
    }
}

void MB_print_state(){
  switch(modbus_dev.state){
          case NO_ERROR:
              console_print(">>Modbus state: success\r\n" );
              break;
          case RCV_address:
              console_print(">>Modbus state: address error\r\n");
              break;
          case CRC_error:
            console_print(">>Modbus state: CRC error\r\n" );
            break;
          case RCV_Empty:
            console_print(">>Modbus state: NO retreive.\r\n");
            break;        
          }
}